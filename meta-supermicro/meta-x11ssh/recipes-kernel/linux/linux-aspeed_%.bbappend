FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-ARM-dts-aspeed-Add-dts-for-Supermicro-X11SSH.patch"
