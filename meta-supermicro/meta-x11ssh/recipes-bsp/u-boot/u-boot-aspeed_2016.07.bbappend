FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-supermicro-x11ssh-serial-routing-for-BMC-on-COM2.patch"
