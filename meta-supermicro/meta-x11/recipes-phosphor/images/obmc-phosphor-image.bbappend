OBMC_IMAGE_EXTRA_INSTALL:append = " x11-powerctrl"
